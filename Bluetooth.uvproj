# Keil uVision project Bluetooth.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Bluetooth
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..\..\ek-tm4c123gxl-boostxl-senshub;..\..\..\..\..\TivaWare_C_Series-2.1.3.156
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\ek-tm4c123gxl-boostxl-senshub\pressure_bmp180\pressure_bmp180.sct
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: Bluetooth.c startup_rvmdk.S
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../utils/: uartstdio.c uartstdio.h
    ../../../../sensorlib/rvmdk/: sensorlib.lib
